# IAR project Kinetis_Master.ewp, settings and files
configuration MK66FX_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option; ..\..\..\Libraries\ASTA_BCN\inc; ..\..\..\Libraries\extra
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Kinetis_Master.srec
  ILINK.IlinkOutputFile: Kinetis_Master.out
  ILINK.IlinkIcfFile: linker\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../../../Libraries/drives/inc/: MK66_port_cfg.h
  group APP/inc
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h
  group APP/src
    ../../USER/src/: isr.c main.c
  group APP/txt
    ../../../: MK66_note.txt PIN.txt
  group ASTA_BCN
    ../../../Libraries/ASTA_BCN/inc/: ALLBCN.h
  group ASTA_BCN/communication
    ../../../Libraries/ASTA_BCN/src/: bluetooth.c
  group ASTA_BCN/control
    ../../../Libraries/ASTA_BCN/src/: algo.c barrier.c control.c crash.c fuzzy.c PID.c
  group ASTA_BCN/memory
    ../../../Libraries/ASTA_BCN/src/: flash.c
  group ASTA_BCN/motor
    ../../../Libraries/ASTA_BCN/src/: encode.c motor.c
  group ASTA_BCN/sensor
    ../../../Libraries/ASTA_BCN/src/: openmv.c pan_infrared.c
  group ASTA_BCN/sensor/mpu6050
    ../../../Libraries/ASTA_BCN/src/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c top6050.c
  group ASTA_BCN/UI
    ../../../Libraries/ASTA_BCN/src/: beep.c interact.c key.c oled.c
  group drives
    ../../../Libraries/drives/src/: common.c misc.c MK66_adc.c MK66_cmt.c MK66_dac.c MK66_dma.c MK66_flash.c MK66_ftm.c MK66_gpio.c MK66_i2c.c MK66_lptmr.c MK66_pit.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_systick.c MK66_uart.c MK66_wdog.c
    ../../../Libraries/ASTA_BCN/src/: K66_tpm.c
  group extra/inc
    ../../../Libraries/extra/: SEEKFREE_7725.h SEEKFREE_FUN.h SEEKFREE_IIC.h SEEKFREE_MPU6050.h SEEKFREE_NRF24L01.h
  group extra/src
    ../../../Libraries/extra/: SEEKFREE_7725.c SEEKFREE_FUN.c SEEKFREE_IIC.c SEEKFREE_MPU6050.c SEEKFREE_NRF24L01.c
  group fatfs/inc
    ../../../Libraries/FatFs/: diskio.h ff.h ffconf.h integer.h
  group fatfs/src
    ../../../Libraries/FatFs/: diskio.c ff.c
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK66F18.s
    ../../../Libraries/startup/DeviceSupport/: system_MK66.c
